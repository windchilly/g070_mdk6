# Keil uVision project G070.uvprojx, settings and files
target G070 (6220000::V6.22::ARMCLANG)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: G070 +hex
  AfterMake: fromelf --text -a -c  --output=G070.dis G070\G070.axf
  AfterMake: fromelf --bin !L --output G070\G070.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ../Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\packages\cmbacktrace;..\packages\simplegui\inc;..\app;..\packages\adlist;..\packages\heap;..\cdos;..\packages\letter-shell-master\src;..\packages\multibutton;..\Src;..\dev_drv;..\packages\umcn\inc;..\packages\broker
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User
    ../Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c board.c
  group libraries
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group CmBacktrace
    ../packages/cmbacktrace/: cm_backtrace.c cmb_fault.S
  group apps
    ../app/: print_task.c statistics_task.c test_task.c button.c general.c oled.c
  group heap
    ../packages/heap/: heap_4.c
  group cdos
    ../cdos/: cd_msg.c cd_schedule.c cd_task.c cd_timer.c cd_service.c
  group lettershell
    ../packages/letter-shell-master/src/: shell_ext.c shell_companion.c shell_cmd_list.c shell.c shell_port.c log.c
  group multibutton
    ../packages/multibutton/: multi_button.c
  group device_drvivers
    ../dev_drv/: adc.c
  group drivers
    ../drv/: drv_adc.c
  group umcn
    ../packages/umcn/src/: uMCN.c
  group broker
    ../packages/broker/: broker_task.c
software components: CMSIS:CORE 6.1.0
